## Kconfig
```kconfig
mainmenu "Kconfig 示例主菜单"

menu "Animal 配置"
    source "project/animal/animal.kconfig"
endmenu
```
